# Keil uVision project INT_COM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: print_wiegand_26_33_v100 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\libreria
  group Source Group 1
    ./: Principal_MF.C uart.c display.c
    ./libreria/: wiegand.c
